# Keil uVision project MainModule_V1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: MainModule +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MAIN.c CONFIG.c CONTROL.c TELE_PACK.c TELE_T_R.c TELE_PARSE.c RELAY.c SCR.c TELE_MANAGE.c SENSOR_T_H.c LUX_LIGHT.c
